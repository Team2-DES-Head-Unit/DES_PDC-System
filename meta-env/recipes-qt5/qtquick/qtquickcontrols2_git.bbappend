DEPENDS += "qtbase qtdeclarative"
